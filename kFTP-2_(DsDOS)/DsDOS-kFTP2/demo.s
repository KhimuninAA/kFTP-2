//
//  demo.s
//  DsDOS-kFTP2
//
//  Created by Алексей Химунин on 12.07.2026.
//

DEM$    4; дЕМОНСТРАЦИЯ ВИДЕО РЕЖИМОВ DSDOS
; (C) сОЛОВЬЕВ д.н. /20.12.98/
; Last changes: 02.04.00
; рУСИФИКАЦИЯ:  14.04.2015

BIOS: EQU 0F000H
DSDOS:EQU 0F360H

ORG 0; ЗНАЧЕНИЕ НЕ ИЗМЕНЯТЬ !!!


JMP START
DB '[COM]'; СИГНАТУРА "КОМПАКТНЫХ" ПРОГРАММ


ExBIOS:; RST_1
JMP BIOS
NOP
NOP
NOP

CLS:
MVI C,31

PRC:; RST_2
PUSH PSW
XRA A
CALL BIOS
POP PSW
RET
NOP


MSG:; RST_3
MVI A,2
CALL BIOS
XRA A
RET
NOP

KEY:; RST_4
MVI A,1
JMP BIOS



START:
; сохранить тип курсора
MVI A,17H
RST 1; CALL BIOS
STA M_TCUR

; сохранить координаты курсора
MVI A,1DH
RST 1; CALL BIOS
SHLD M_CURS

; переключение на теневой экран
MVI C,1
MVI A,14H
RST 1; CALL BIOS

; установит цветной режим отобр-я
MVI C,1
MVI A,10H
RST 1; CALL BIOS

LXI H,T_ZAST
RST 3; CALL MSG

; открыть окно
LXI H,0100H
LXI D,1E30H
CALL PrWIND

; распечатка знакогенератора
CALL PrFONT

LXI H,T_FONT
CALL PrHELP

; демонстрация меню
LXI H,T_MENU
RST 3; CALL MSG
MVI A,15
RST 1; CALL BIOS

MVI C,1EH
MVI A,12H
RST 1; CALL BIOS

; открыть окно 2
LXI H,0508H
LXI D,1021H
CALL PrWIND

LXI H,T_CODE
RST 3; CALL MSG

CYCL2:
; ввод символа с клавиатуры
RST 4; CALL KEY
CPI 3
JZ EXIT
MOV C,A
;MVI A,4
;RST 1; CALL BIOS
RST 2; CALL PRC
JMP CYCL2

EXIT:
; восстановить вид курсора
LDA M_TCUR
MOV C,A
MVI A,16H
RST 1; CALL BIOS

; восстановить координаты курсора
LHLD M_CURS
CALL SetCUR
JMP DSDOS


PrWIND:
; открытие окна
; I: [L]-XPOS, [H]-YPOS
;    [E]-LONG, [D]-HIGH
PUSH H
MVI A,18H
RST 1; CALL BIOS
XCHG
INR H
MVI A,1AH
RST 1; CALL BIOS

DCR H
DCR H
DCR H
DCR L
DCR L
XCHG
CALL CLS
MVI A,11H
RST 1; CALL BIOS
MOV A,C
STA M_MODE
MVI C,0
MVI A,10H
RST 1; CALL BIOS

MVI C,95H
RST 2; CALL PRC
MOV B,E
MVI C,99H
RST 2; CALL PRC
DCR B
JNZ $-4
MVI C,88H
RST 2; CALL PRC
LXI H,0100H
CALL PRVERT
MVI C,94H
RST 2; CALL PRC
MOV B,E
MVI C,99H
RST 2; CALL PRC
DCR B
JNZ $-4
MVI C,89H
RST 2; CALL PRC
MOV L,E
INR L
MVI H,1
CALL PRVERT
XCHG
MVI A,1AH
RST 1; CALL BIOS
POP H
INR H
INR L
MVI A,18H
RST 1; CALL BIOS
LDA M_MODE
MOV C,A
MVI A,10H
RST 1; JMP BIOS
RET


PRVERT:
MOV B,D
CALL SetCUR
MVI C,87H
XRA A
RST 1; CALL BIOS
INR H
DCR B
JNZ PRVERT+1

SetCUR:
MVI A,1CH
RST 1; JMP BIOS
RET


PrHELP:
; печать сообщения в HELP-строку
; I: [HL]-MESSAGE
PUSH H
MVI A,12
RST 1; CALL BIOS
POP H
RST 3; CALL MSG
RST 4; CALL KEY
PUSH PSW
MVI A,13
RST 1; CALL BIOS
POP PSW
CPI 3
JZ EXIT
CPI 27
JZ EXIT
CPI 13
RET

PrFONT:
; распечатка знакогенератора
MVI C,0E0H
MVI A,12H
RST 1; CALL BIOS
LXI H,0
MVI C,32
MVI D,14

PRFNT1:
PUSH H
MVI E,16

PRFNT2:
CALL SetCUR
RST 2; CALL PRC
INR L
INR L
INR L
INR C
DCR E
JNZ PRFNT2
POP H
INR H
INR H
DCR D
JNZ PRFNT1
RET

; *** текстовые сообщения ***

T_ZAST:DB 14,1EH,31
DB 'дЕМОНСТРАЦИЯ ВВОДА-ВЫВОДА ос DSDOS',0

T_FONT:DB 14,0E1H,31
DB 'зНАКОГЕНЕРАТОР DSDOS. [..]-ДАЛЬШЕ, [AP2]-ВЫХОД',7,0

T_MENU:DB 14,1EH,31
DB 1,32+7,2,32+3
DB '* сЕРВИСНОЕ МЕНЮ ПОЛЬЗОВАТЕЛЯ *'
DB 1,32+9,2,32+6
DB 'кЛАВИШИ [╟, ╠, ╨] - ВЫБОР'
DB 1,32+9,2,32+8
DB '[AP2] - ДАЛЬШЕ...',0

T_CODE:DB 14,0EH,31
DB 'кЛАВИАТУРНЫЙ ВВОД:',13,0


M_TCUR:DB 0
M_CURS:DW 0
M_MODE:DB 0

END
